require trik-base-v2.bb

IMAGE_INSTALL += "\
		mono \
		fsharp \
		python-pip \
		python-numpy \
		python-pyqt \
		packagegroup-core-buildessential\
		ldd\
		file\
"
# trik-ros roslaunch"

